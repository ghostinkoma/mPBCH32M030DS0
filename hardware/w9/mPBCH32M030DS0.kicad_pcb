# Repository ghostinkoma/mPBCH32M030DS0

## KiCad design hardware/w9/mPBCH32M030DS0.kicad_pcb

Notes on the sheet:
mPBCH32M030DS0 Rev 0.4 MCU モジュール — CH32M030C8U7 (QFN48), ブレッドボード対応 DIP-42 (列間 0.6in)
・2 層 22.86 x 53.34mm (2.54mm 格子で 9 x 21 マス)。左右 21 ピン x 2 列, 列間 17.78mm
ピンヘッダは裏から (ブレッドボード / 子基板用) でも表から (ジャンパワイヤ用) でも実装できる
・左列 J1: USB VBUS / 電源 / SDI / センサ (相電圧・ホール・電流・NTC)。右列 J2: ゲート駆動 x12 / UART / I2C / GPIO
・LED はすべてモジュール上 (子基板の部品面はヒートシンク側のため): 電源 x3, 状態, ゲート確認 x8
・パワー段子基板 (A: TPN1R603PL / B: TKR74F04PB 24V / C: MTN2306AN3) は左右対称のピンソケットで受ける
・電圧に依存する部品 (TVS, VBUS 分圧, バルク容量) は子基板側。モジュールは電圧に依存しない
詳細は README.md, docs/stacking.md, docs/design.md を参照。

Parts:
C7: 10nF/50V; C_0402_1005Metric; MPN Murata GRM155R71H103KA88D (X7R 1005)
D2: GREEN 5V; LED_0603_1608Metric; MPN 1608 チップ LED
D4: MMSZ5254B 27V; D_SOD-123; MPN MMSZ5254B (27V 500mW, VHV 絶対最大 30V の保護)
D5, D6: B5819W; D_SOD-123; MPN B5819W (40V 1A ショットキー)
D7: RED VBUS; LED_0603_1608Metric; MPN 1608 チップ LED
D8: GREEN 3V3; LED_0603_1608Metric; MPN 1608 チップ LED
R3: 2.2k; R_0402_1005Metric
R4: 15k; R_0402_1005Metric
R5: 1.5k; R_0402_1005Metric
R7: 120k 1%; R_0402_1005Metric
R8: 10k 1%; R_0402_1005Metric
R10: 47R; R_0603_1608Metric

Connections:
+3V3: R5.1; also elsewhere on the board
+5V: R3.1; also elsewhere on the board
GND: C7.2, D2.1 (K), D4.2 (A), D7.1 (K), D8.1 (K), R8.2; also elsewhere on the board
LED_D2_A: D2.2 (A), R3.2
LED_D7_A: D7.2 (A), R4.2
LED_D8_A: D8.2 (A), R5.2
USB_VBUS: R7.1; also elsewhere on the board
USB_VBUS_F: D6.2 (A); also elsewhere on the board
USB_VBUS_SNS: C7.1, R7.2, R8.1; also elsewhere on the board
VBUS: D5.2 (A), R4.1; also elsewhere on the board
VHV: D4.1 (K), R10.2; also elsewhere on the board
VHV_IN: D5.1 (K), D6.1 (K), R10.1

Notes on the sheet:
MCU 電源 VHV (VBUS ピン / USB 5V のダイオード OR + 27V クランプ)
電源表示 LED (モジュール上面: 子基板を付けても見える)
USB VBUS 監視 (PA2)
VBUS ピン (子基板のモータ電源) か USB 5V のどちらかで MCU が動く。ブレッドボード単体は USB 給電のみで可。
R10 47Ω + D4 27V: 24V 系のサージで VHV が 30V を超えないようにする。
D7: モータ電源 VBUS D2: +5V (子基板の 78L05) D8: VDD33 (1.5k で約 0.9mA, VDD33 負荷 ≤20mA)
USB_VBUS / 13 → PA2 (20V → 1.54V)。PD 契約後の電圧確認に使う。

Parts:
C130: 4.7nF/100V; C_0603_1608Metric; MPN Samsung CL10B472KC8NNNC (X7R 100V 1608)
C131, C132: 30pF C0G; C_0402_1005Metric; MPN Murata GRM1555C1H300JA01D (C0G 1005)
C133: 0.1uF/50V; C_0402_1005Metric; MPN Murata GRM155R71H104KE14D (X7R 1005)
F2: PTC 0.5A; Fuse_1206_3216Metric; MPN ポリスイッチ 0.5A 1206 (例: Bourns MF-NSMF050)
J8: USB-C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; MPN GCT USB4105-GF-A (USB-C 16P)
R130: 1M; R_0402_1005Metric
R131: 10k; R_0402_1005Metric
SW1: RESET; SW_SPST_B3U-1000P; MPN Omron B3U-1000P (3x2.5mm SMD タクト, 上押し)
U3: USBLC6-2SC6; SOT-23-6; MPN ST USBLC6-2SC6 (D+/D- ESD 保護, 基準は +3V3)
Y1: 8MHz CL=20pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN 8MHz 3225 4pad, CL=20pF, ESR≤60Ω (例: Ab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

Connections:
+3V3: R131.1, U3.5 (VBUS); also elsewhere on the board
GND: C130.2, C131.2, C132.2, C133.2, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), R130.2, SW1.2, U3.2 (GND), Y1.2 (GND), Y1.4 (GND); also elsewhere on the board
USB_CC1: J8.A5 (CC1); also elsewhere on the board
USB_CC2: J8.B5 (CC2); also elsewhere on the board
USB_DN: J8.A7 (D-), J8.B7 (D-), U3.3 (IO2), U3.4 (IO2); also elsewhere on the board
USB_DP: J8.A6 (D+), J8.B6 (D+), U3.1 (IO1), U3.6 (IO1); also elsewhere on the board
USB_SHIELD: C130.1, J8.S1 (SHIELD), R130.1
USB_VBUS: F2.1, J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS); also elsewhere on the board
USB_VBUS_F: F2.2; also elsewhere on the board
XI: C131.1, Y1.1; also elsewhere on the board
XO: C132.1, Y1.3; also elsewhere on the board
nRST: C133.1, R131.2, SW1.1; also elsewhere on the board

Notes on the sheet:
USB Type-C (USB2.0 FS デバイス / PD シンク)
水晶発振子 (HSE 8MHz)
リセット (RST = PC0) ※ 上面
CC1/CC2 = PA0/PA1 (Rd 5.1kΩ 内蔵)。D+/D- = PB0/PB1。USB_VBUS はモジュール端子 J1 の 1/2 番 (子基板の PD 給電経路) へ。
注意: PD 契約後は USB_VBUS が 9〜15V になる。ブレッドボードでは USB_VBUS ピンに 5V 部品を直結しないこと。
XI=PB5 / XO=PB6。C = 2 x (CL - 浮遊容量 約5pF) = 30pF。
RST ピンはユーザオプションバイトで有効化 (RST_PIN_SEL=0 → PC0)。

Parts:
C10: 10uF/50V; C_1206_3216Metric; MPN Murata GRM31CR61H106KA12L (X5R 1206)
C11, C13, C15, C18: 0.1uF/50V; C_0402_1005Metric; MPN Murata GRM155R71H104KE14D (X7R 1005)
C12: 10uF/25V; C_0805_2012Metric; MPN Murata GRM21BR61E106KA73L (X5R 2012)
C14: 4.7uF/16V; C_0603_1608Metric; MPN Samsung CL10A475KO8NNNC (X5R 1608)
C16: 10nF/50V; C_0402_1005Metric; MPN Murata GRM155R71H103KA88D (X7R 1005)
C17: 1nF C0G; C_0402_1005Metric; MPN Murata GRM1555C1H102JA01D (C0G 1005)
C19, C20: 2.2nF C0G; C_0402_1005Metric; MPN Murata GRM1555C1H222JA01D (C0G 1005)
C21, C22, C23, C24: 2.2uF/25V; C_0603_1608Metric; MPN Murata GRM188R61E225KA12D (X5R 1608)
R13: 1k; R_0402_1005Metric
R14: 12k 1%; R_0402_1005Metric
R15: 1k 1%; R_0402_1005Metric
R16, R17, R18, R19: 100R 1%; R_0402_1005Metric
U1: CH32M030C8U7; CH32M030DS0_QFN48; MPN WCH CH32M030C8U7 (QFN48 5x5mm 0.35mm pi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

Connections:
+3V3: C14.1, C15.1, R14.1, U1.33 (PC4); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, R15.2, U1.0 (GND), U1.49 (GND(EP)); also elsewhere on the board
GPIO_PC4: U1.31 (PC1/T3C2); also elsewhere on the board
GPIO_PC5: U1.32 (PC3); also elsewhere on the board
HO0: U1.13 (VS0); also elsewhere on the board
HO1: U1.17 (VS1); also elsewhere on the board
HO2: U1.21 (VS2); also elsewhere on the board
HO3: U1.25 (VS3); also elsewhere on the board
I2C_SCL: U1.4 (PA13/QII2/A18); also elsewhere on the board
I2C_SDA: U1.3 (PA12/QII1/A19); also elsewhere on the board
IA_N: C19.2, R17.2, U1.45 (PA6/ISINK1/CM3N1)
IA_P: C19.1, R16.2, U1.46 (PA7/ISINK2/CM3N2/A2)
IBUS_F: C17.1, R13.2, U1.6 (PA15/T1BK/Q_DET2/A10); also elsewhere on the board
IB_N: C20.2, R19.2, U1.48 (ISP1)
IB_P: C20.1, R18.2, U1.47 (PA8/ISN1/CM3O/A7)
ISA_SEL: R16.1; also elsewhere on the board
ISB_SEL: R18.1; also elsewhere on the board
ISH: R13.1, R17.1, R19.1; also elsewhere on the board
LO0: U1.10 (PB5/XI/CM2P/A3); also elsewhere on the board
LO1: U1.14 (VB0); also elsewhere on the board
LO2: U1.18 (VB1); also elsewhere on the board
LO3: U1.22 (VB2); also elsewhere on the board
NTC: U1.41 (PB0/UDP/T2C2_/CM3P1/A11); also elsewhere on the board
OCP_REF: C18.1, R14.2, R15.1, U1.5 (PA14/Q_DET1/A9)
PD_PWR_EN: U1.30 (PC0/T1C4/T3C1); also elsewhere on the board
QII_IN: U1.1 (PA10/ISP2); also elsewhere on the board
SENS_U: U1.42 (PB1/UDM/T2C3_/CM3P2/A12); also elsewhere on the board
SENS_V: U1.44 (PA5/ISRC2/CM3N0/A6); also elsewhere on the board
SENS_W: U1.43 (PA4/ISRC1/A5); also elsewhere on the board
SW0: C21.2, U1.11 (PB6/XO/CM2N/A4); also elsewhere on the board
SW1: C22.2, U1.15 (PB9/T1C1/HO0); also elsewhere on the board
SW2: C23.2, U1.19 (PB11/T1C2/HO1); also elsewhere on the board
SW3: C24.2, U1.23 (PB13/T1C3/T2C1/HO2); also elsewhere on the board
SWDIO: U1.38 (PA1/CC2R/A14); also elsewhere on the board
UART_RX: U1.29 (PB7); also elsewhere on the board
UART_TX: U1.28 (VDD8); also elsewhere on the board
USB_CC1: U1.35 (VDD33); also elsewhere on the board
USB_CC2: U1.36 (VHV); also elsewhere on the board
USB_DN: U1.40 (PA3/SWIO/CC4/T2C1_/SDA_/CM3P0/A16); also elsewhere on the board
USB_DP: U1.39 (PA2/SWCK/CC3/SCL_/A15); also elsewhere on the board
USB_VBUS_SNS: U1.37 (PA0/CC1R/A13); also elsewhere on the board
VB0: C21.1, U1.12 (PB8/T1C1N/LO0)
VB1: C22.1, U1.16 (PB10/T1C2N/LO1)
VB2: C23.1, U1.20 (PB12/T1C3N/T2C1N/LO2)
VB3: C24.1, U1.24 (PB14/T3C2N/T2C2N/LO3)
VBUS_SNS: C16.1, U1.7 (PB2/T2C4_/SDA/CM3N3/A0); also elsewhere on the board
VDD8: C12.1, C13.1, U1.26 (VB3)
VHV: C10.1, C11.1, U1.34 (PC5/HVIO); also elsewhere on the board
XI: U1.8 (PB3/SCL/CM3P3/A1); also elsewhere on the board
XO: U1.9 (PB4/V_DET/A17); also elsewhere on the board
nFAULT: U1.2 (PA11/ISN2/A8); also elsewhere on the board
nRST: U1.27 (PB15/T3C2/T2C2/HO3); also elsewhere on the board

Notes on the sheet:
電源デカップリング (ピン直近)
バス電流フィルタ / 過電流比較の閾値
電流アンプ入力 (OPA3=ISP1 / OPA4=ISP2 → ADC 内部接続)
ブートストラップ容量 (VBx-VSx, MCU ピン直近)
VHV 5〜28V (≥10uF, 1206/50V)。VDD8 5/8/9/10V (≥10uF, 2012/25V)。VDD33 4.7uF (1608/16V)。
LDO 負荷上限: VDD8 35mA (ゲート駆動+VDD33 含む) / VDD33 20mA。QFN 裏面パッドが唯一の GND。
VBUS_SNS (PB4 = ADC17 + OVP リセット) の分圧抵抗は子基板側 (電圧系ごとに定数が違う)。C16 は MCU 直近の平滑。
PB3: バス電流 (10mΩ: 1A = 10mV) + CMP3_P3。PB2: 閾値 254mV (25.4A) = CMP3_N3。
OPA3 出力 → ADC_IN9, OPA4 出力 → ADC_IN10 (チップ内部接続)。ゲイン 4/8/16/55。
2.2uF 1608 (DC バイアス後 ≈1.3uF): Qg 41nC で降下 32mV, Qg ≈150nC でも ≈0.12V。

Parts:
C100, C101, C102: 1nF/50V; C_0402_1005Metric; MPN Murata GRM155R71H102KA01D (X7R 1005)
C103, C105: 0.1uF/50V; C_0402_1005Metric; MPN Murata GRM155R71H104KE14D (X7R 1005)
D3: GREEN STAT; LED_0603_1608Metric; MPN 1608 チップ LED
D10: RED GH0; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D11: GREEN GL0; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D12: RED GH1; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D13: GREEN GL1; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D14: RED GH2; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D15: GREEN GL2; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D16: RED GH3; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
D17: GREEN GL3; LED_0402_1005Metric; MPN 1005 チップ LED (例: Kingbright APHHS1005)
J1: EDGE_L; PinHeader_1x21_P2.54mm_Vertical; MPN 2.54mm 1x21 ピンヘッダ (裏 or 表から実装)
J2: EDGE_R; PinHeader_1x21_P2.54mm_Vertical; MPN 2.54mm 1x21 ピンヘッダ (裏 or 表から実装)
JP2: SEL_U; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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; MPN はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホー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
JP3: SEL_V; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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; MPN はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホー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
JP4: SEL_W; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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; MPN はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホー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
JP8: QII_SRC; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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; MPN はんだジャンパ 3 端子 (1-2 ブリッジ済み: TACH_IN / 2-3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
R50, R51, R52, R53, R54, R55, R56, R57: 22k; R_0402_1005Metric
R100, R103, R106, R123: 4.7k; R_0402_1005Metric
R101, R104, R107, R112: 1k; R_0402_1005Metric
R110: 10k (DNP); R_0402_1005Metric; not fitted
R111, R122: 10k; R_0402_1005Metric
R114, R115: 4.7k (DNP); R_0402_1005Metric; not fitted
R120: 470R; R_0402_1005Metric
SW2: USER/BOOT; SW_SPST_B3U-1000P; MPN Omron B3U-1000P (3x2.5mm SMD タクト, 上押し)

Connections:
+3V3: D3.2 (A), J1.6, R100.2, R103.2, R106.2, R110.1, R111.1, R114.1, R115.1, R122.1; also elsewhere on the board
+5V: J1.7; also elsewhere on the board
BEMF_U: J1.11, JP2.1
BEMF_V: J1.12, JP3.1
BEMF_W: J1.13, JP4.1
GLEDH0: D10.2 (A), R50.2
GLEDH1: D12.2 (A), R52.2
GLEDH2: D14.2 (A), R54.2
GLEDH3: D16.2 (A), R56.2
GLEDL0: D11.2 (A), R51.2
GLEDL1: D13.2 (A), R53.2
GLEDL2: D15.2 (A), R55.2
GLEDL3: D17.2 (A), R57.2
GND: C100.2, C101.2, C102.2, C103.2, D11.1 (K), D13.1 (K), D15.1 (K), D17.1 (K), J1.21, J2.1, J2.21, SW2.2; also elsewhere on the board
GPIO_PC4: J1.4, R111.2, R112.2, SW2.1; also elsewhere on the board
GPIO_PC5: J1.5; also elsewhere on the board
HALL_A: C100.1, JP2.3, R101.2
HALL_A_IN: J1.14, R100.1, R101.1
HALL_B: C101.1, JP3.3, R104.2
HALL_B_IN: J1.15, R103.1, R104.1
HALL_C: C102.1, JP4.3, R107.2
HALL_C_IN: J1.16, R106.1, R107.1
HO0: J2.14, R50.1; also elsewhere on the board
HO1: J2.11, R52.1; also elsewhere on the board
HO2: J2.8, R54.1; also elsewhere on the board
HO3: J2.5, R56.1; also elsewhere on the board
I2C_SCL: J2.18, R115.2; also elsewhere on the board
I2C_SDA: J2.19, R114.2; also elsewhere on the board
IBUS_F: JP8.3; also elsewhere on the board
ISA_SEL: J1.17; also elsewhere on the board
ISB_SEL: J1.19; also elsewhere on the board
ISH: J1.18; also elsewhere on the board
LED_STAT_K: D3.1 (K), R112.1
LO0: J2.16, R51.1; also elsewhere on the board
LO1: J2.13, R53.1; also elsewhere on the board
LO2: J2.10, R55.1; also elsewhere on the board
LO3: J2.7, R57.1; also elsewhere on the board
NTC: C103.1, J1.10, R110.2; also elsewhere on the board
PD_PWR_EN: J1.3; also elsewhere on the board
QII_IN: C105.2; also elsewhere on the board
QII_SRC: C105.1, JP8.2
SENS_U: JP2.2; also elsewhere on the board
SENS_V: JP3.2; also elsewhere on the board
SENS_W: JP4.2; also elsewhere on the board
SW0: D10.1 (K), J2.15; also elsewhere on the board
SW1: D12.1 (K), J2.12; also elsewhere on the board
SW2: D14.1 (K), J2.9; also elsewhere on the board
SW3: D16.1 (K), J2.6; also elsewhere on the board
SWDIO: J1.8; also elsewhere on the board
TACH_IN: J1.20, R123.1
TACH_R: JP8.1, R123.2
UART_RX: J2.2; also elsewhere on the board
UART_TX: J2.3; also elsewhere on the board
USB_VBUS: J1.1, J1.2; also elsewhere on the board
VBUS: J1.9; also elsewhere on the board
VBUS_SNS: J2.17; also elsewhere on the board
nFAULT: R120.2, R122.2; also elsewhere on the board
nFAULT_IN: J2.20, R120.1
nRST: J2.4; also elsewhere on the board

Notes on the sheet:
DIP 端子 (2.54mm, 21 ピン x 2 列, 列間 17.78mm)
ゲート確認 LED (モジュール上面に 8 個: 子基板の部品面はヒートシンク側で見えないため)
3 相センシング選択 (はんだジャンパ, 出荷時 1-2 = 相電圧) / QII 入力選択
ホール入力 / USER・BOOT + 状態 LED / I2C / nFAULT / NTC
子基板は同じピン番号のソケット (左右対称) で受ける。
H: HOx-SWx (ハイサイドのゲート電圧), L: LOx-GND。約 0.35mA @ VDD8=10V。PWM のデューティで明るさが変わる。
子基板を付けずブレッドボードで使うときも同じ: BEMF_x / HALL_x_IN ピンに信号を入れる。
NTC 本体は子基板 (MOSFET 近傍)。PA4 の ISOURCE1 で駆動。I2C プルアップ R114/R115 は必要時のみ。

Board: 2 copper layers, 22.9 x 53.3 mm, 90 parts (50 on the bottom side), 83 nets.

File hardware/nopour/bom.csv:

Qty,References,Value,Footprint,MPN / 備考,DNP
2,C7 C16,10nF/50V,Capacitor_SMD:C_0402_1005Metric,Murata GRM155R71H103KA88D (X7R 1005),
1,C10,10uF/50V,Capacitor_SMD:C_1206_3216Metric,Murata GRM31CR61H106KA12L (X5R 1206),
7,C11 C13 C15 C18 C103 C105 C133,0.1uF/50V,Capacitor_SMD:C_0402_1005Metric,Murata GRM155R71H104KE14D (X7R 1005),
1,C12,10uF/25V,Capacitor_SMD:C_0805_2012Metric,Murata GRM21BR61E106KA73L (X5R 2012),
1,C14,4.7uF/16V,Capacitor_SMD:C_0603_1608Metric,Samsung CL10A475KO8NNNC (X5R 1608),
1,C17,1nF C0G,Capacitor_SMD:C_0402_1005Metric,Murata GRM1555C1H102JA01D (C0G 1005),
2,C19 C20,2.2nF C0G,Capacitor_SMD:C_0402_1005Metric,Murata GRM1555C1H222JA01D (C0G 1005),
4,C21 C22 C23 C24,2.2uF/25V,Capacitor_SMD:C_0603_1608Metric,Murata GRM188R61E225KA12D (X5R 1608),
3,C100 C101 C102,1nF/50V,Capacitor_SMD:C_0402_1005Metric,Murata GRM155R71H102KA01D (X7R 1005),
1,C130,4.7nF/100V,Capacitor_SMD:C_0603_1608Metric,Samsung CL10B472KC8NNNC (X7R 100V 1608),
2,C131 C132,30pF C0G,Capacitor_SMD:C_0402_1005Metric,Murata GRM1555C1H300JA01D (C0G 1005),
1,D2,GREEN 5V,LED_SMD:LED_0603_1608Metric,1608 チップ LED,
1,D3,GREEN STAT,LED_SMD:LED_0603_1608Metric,1608 チップ LED,
1,D4,MMSZ5254B 27V,Diode_SMD:D_SOD-123,"MMSZ5254B (27V 500mW, VHV 絶対最大 30V の保護)",
2,D5 D6,B5819W,Diode_SMD:D_SOD-123,B5819W (40V 1A ショットキー),
1,D7,RED VBUS,LED_SMD:LED_0603_1608Metric,1608 チップ LED,
1,D8,GREEN 3V3,LED_SMD:LED_0603_1608Metric,1608 チップ LED,
1,D10,RED GH0,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D11,GREEN GL0,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D12,RED GH1,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D13,GREEN GL1,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D14,RED GH2,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D15,GREEN GL2,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D16,RED GH3,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,D17,GREEN GL3,LED_SMD:LED_0402_1005Metric,1005 チップ LED (例: Kingbright APHHS1005),
1,F2,PTC 0.5A,Fuse:Fuse_1206_3216Metric,ポリスイッチ 0.5A 1206 (例: Bourns MF-NSMF050),
1,J1,EDGE_L,Connector_PinHeader_2.54mm:PinHeader_1x21_P2.54mm_Vertical,2.54mm 1x21 ピンヘッダ (裏 or 表から実装),
1,J2,EDGE_R,Connector_PinHeader_2.54mm:PinHeader_1x21_P2.54mm_Vertical,2.54mm 1x21 ピンヘッダ (裏 or 表から実装),
1,J8,USB-C,Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,GCT USB4105-GF-A (USB-C 16P),
1,JP2,SEL_U,Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberLabels,はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホール),
1,JP3,SEL_V,Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberLabels,はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホール),
1,JP4,SEL_W,Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberLabels,はんだジャンパ 3 端子 (1-2 ブリッジ済み: 相電圧 / 2-3: ホール),
1,JP8,QII_SRC,Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberLabels,はんだジャンパ 3 端子 (1-2 ブリッジ済み: TACH_IN / 2-3: バス電流リップル),
1,R3,2.2k,Resistor_SMD:R_0402_1005Metric,,
1,R4,15k,Resistor_SMD:R_0402_1005Metric,,
1,R5,1.5k,Resistor_SMD:R_0402_1005Metric,,
1,R7,120k 1%,Resistor_SMD:R_0402_1005Metric,,
1,R8,10k 1%,Resistor_SMD:R_0402_1005Metric,,
1,R10,47R,Resistor_SMD:R_0603_1608Metric,,
5,R13 R101 R104 R107 R112,1k,Resistor_SMD:R_0402_1005Metric,,
1,R14,12k 1%,Resistor_SMD:R_0402_1005Metric,,
1,R15,1k 1%,Resistor_SMD:R_0402_1005Metric,,
4,R16 R17 R18 R19,100R 1%,Resistor_SMD:R_0402_1005Metric,,
8,R50 R51 R52 R53 R54 R55 R56 R57,22k,Resistor_SMD:R_0402_1005Metric,,
4,R100 R103 R106 R123,4.7k,Resistor_SMD:R_0402_1005Metric,,
1,R110,10k,Resistor_SMD:R_0402_1005Metric,,DNP
3,R111 R122 R131,10k,Resistor_SMD:R_0402_1005Metric,,
2,R114 R115,4.7k,Resistor_SMD:R_0402_1005Metric,,DNP
1,R120,470R,Resistor_SMD:R_0402_1005Metric,,
1,R130,1M,Resistor_SMD:R_0402_1005Metric,,
1,SW1,RESET,Button_Switch_SMD:SW_SPST_B3U-1000P,"Omron B3U-1000P (3x2.5mm SMD タクト, 上押し)",
1,SW2,USER/BOOT,Button_Switch_SMD:SW_SPST_B3U-1000P,"Omron B3U-1000P (3x2.5mm SMD タクト, 上押し)",
1,U1,CH32M030C8U7,CH32M030DS0_QFN48:CH32M030DS0_QFN48,WCH CH32M030C8U7 (QFN48 5x5mm 0.35mm pitch),
1,U3,USBLC6-2SC6,Package_TO_SOT_SMD:SOT-23-6,"ST USBLC6-2SC6 (D+/D- ESD 保護, 基準は +3V3)",
1,Y1,8MHz CL=20pF,Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm,"8MHz 3225 4pad, CL=20pF, ESR≤60Ω (例: Abracon ABM8-8.000MHZ-B2-T)",
